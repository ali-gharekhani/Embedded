<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USB_HOST_MS.ewp</path>
  </project>
  <batchBuild />
</workspace>
